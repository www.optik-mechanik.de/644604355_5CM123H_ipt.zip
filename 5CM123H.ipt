# Autodesk Inventor part: 5CM123H
## iProperties
Created: 2007-06
Part Number: 5CM123H
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
